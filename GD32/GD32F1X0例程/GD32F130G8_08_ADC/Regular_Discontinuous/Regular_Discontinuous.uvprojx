# Keil uVision project Regular_Discontinuous.uvprojx, settings and files
target Regular_Discontinuous (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F130G8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.1.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Regular_Discontinuous +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F130_150
  c include: .\App;.\CMSIS;.\StdPeriph_Driver\Include;.\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group App
    ./App/: gd32f1x0_it.c main.c systick.c
  group CMSIS
    ./CMSIS/: startup_gd32f1x0.s system_gd32f1x0.c
  group Doc
    ./Doc/: readme.txt
  group StdPeriph_Driver
    ./StdPeriph_Driver/Source/: gd32f1x0_adc.c gd32f1x0_can.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_misc.c gd32f1x0_opa.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_slcd.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group Utilities
    ./Utilities/: adc.c led.c usart.c
